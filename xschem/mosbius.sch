v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {BUS A[6:1]} 2030 -2820 0 0 1 1 {}
T {BUS B[6:1]} 3510 -2840 0 0 1 1 {}
T {BUS A/B CONNECTOR} 2740 270 0 0 1 1 {}
T {5T OTA} 340 -2190 0 0 1 1 {}
T {N-CHNL MIRRORS} 200 -1680 0 0 1 1 {}
T {P-CHNL MIRRORS} 920 -1680 0 0 1 1 {}
T {N-CHNL DIFF PAIR} 200 -1150 0 0 1 1 {}
T {P-CHNL DIFF PAIR} 920 -1150 0 0 1 1 {}
T {NMOS (BUS A)} 190 -640 0 0 1 1 {}
T {PMOS (BUS A)} 940 -640 0 0 1 1 {}
T {NMOS (BUS B)} 180 -170 0 0 1 1 {}
T {PMOS (BUS B)} 930 -170 0 0 1 1 {}
N 310 -2050 340 -2050 {
lab=VAPWR}
N 310 -2030 340 -2030 {
lab=VDPWR}
N 310 -1840 340 -1840 {
lab=VGND}
N 1030 -1540 1060 -1540 {
lab=VAPWR}
N 1030 -1520 1060 -1520 {
lab=VDPWR}
N 1030 -1350 1060 -1350 {
lab=VGND}
N 310 -1540 340 -1540 {
lab=VAPWR}
N 310 -1520 340 -1520 {
lab=VDPWR}
N 310 -1350 340 -1350 {
lab=VGND}
N 310 -1010 340 -1010 {
lab=VAPWR}
N 310 -990 340 -990 {
lab=VDPWR}
N 310 -800 340 -800 {
lab=VGND}
N 1030 -1010 1060 -1010 {
lab=VAPWR}
N 1030 -990 1060 -990 {
lab=VDPWR}
N 1030 -800 1060 -800 {
lab=VGND}
N 310 -490 340 -490 {
lab=VAPWR}
N 310 -470 340 -470 {
lab=VDPWR}
N 310 -310 340 -310 {
lab=VGND}
N 310 -30 340 -30 {
lab=VAPWR}
N 310 -10 340 -10 {
lab=VDPWR}
N 310 150 340 150 {
lab=VGND}
N 1030 -490 1060 -490 {
lab=VAPWR}
N 1030 -470 1060 -470 {
lab=VDPWR}
N 1030 -310 1060 -310 {
lab=VGND}
N 1030 -30 1060 -30 {
lab=VAPWR}
N 1030 -10 1060 -10 {
lab=VDPWR}
N 1030 150 1060 150 {
lab=VGND}
N 2330 -2610 2360 -2610 {
lab=VAPWR}
N 2330 -2590 2360 -2590 {
lab=VDPWR}
N 2330 -2530 2360 -2530 {
lab=VGND}
N 2330 -2550 2510 -2550 {bus=true
lab=bus_A[6:1]}
N 2330 -2450 2360 -2450 {
lab=VAPWR}
N 2330 -2430 2360 -2430 {
lab=VDPWR}
N 2330 -2370 2360 -2370 {
lab=VGND}
N 2330 -2290 2360 -2290 {
lab=VAPWR}
N 2330 -2270 2360 -2270 {
lab=VDPWR}
N 2330 -2210 2360 -2210 {
lab=VGND}
N 2330 -2130 2360 -2130 {
lab=VAPWR}
N 2330 -2110 2360 -2110 {
lab=VDPWR}
N 2330 -2050 2360 -2050 {
lab=VGND}
N 2330 -2070 2510 -2070 {bus=true
lab=bus_A[6:1]}
N 2330 -1970 2360 -1970 {
lab=VAPWR}
N 2330 -1950 2360 -1950 {
lab=VDPWR}
N 2330 -1890 2360 -1890 {
lab=VGND}
N 2330 -1810 2360 -1810 {
lab=VAPWR}
N 2330 -1790 2360 -1790 {
lab=VDPWR}
N 2330 -1730 2360 -1730 {
lab=VGND}
N 2330 -1650 2360 -1650 {
lab=VAPWR}
N 2330 -1630 2360 -1630 {
lab=VDPWR}
N 2330 -1570 2360 -1570 {
lab=VGND}
N 2330 -1490 2360 -1490 {
lab=VAPWR}
N 2330 -1470 2360 -1470 {
lab=VDPWR}
N 2330 -1410 2360 -1410 {
lab=VGND}
N 2330 -1330 2360 -1330 {
lab=VAPWR}
N 2330 -1310 2360 -1310 {
lab=VDPWR}
N 2330 -1250 2360 -1250 {
lab=VGND}
N 2330 -1170 2360 -1170 {
lab=VAPWR}
N 2330 -1150 2360 -1150 {
lab=VDPWR}
N 2330 -1090 2360 -1090 {
lab=VGND}
N 2330 -1010 2360 -1010 {
lab=VAPWR}
N 2330 -990 2360 -990 {
lab=VDPWR}
N 2330 -930 2360 -930 {
lab=VGND}
N 2330 -850 2360 -850 {
lab=VAPWR}
N 2330 -830 2360 -830 {
lab=VDPWR}
N 2330 -770 2360 -770 {
lab=VGND}
N 2330 -690 2360 -690 {
lab=VAPWR}
N 2330 -670 2360 -670 {
lab=VDPWR}
N 2330 -610 2360 -610 {
lab=VGND}
N 2330 -530 2360 -530 {
lab=VAPWR}
N 2330 -510 2360 -510 {
lab=VDPWR}
N 2330 -450 2360 -450 {
lab=VGND}
N 2330 -370 2360 -370 {
lab=VAPWR}
N 2330 -350 2360 -350 {
lab=VDPWR}
N 2330 -290 2360 -290 {
lab=VGND}
N 2330 -210 2360 -210 {
lab=VAPWR}
N 2330 -190 2360 -190 {
lab=VDPWR}
N 2330 -130 2360 -130 {
lab=VGND}
N 310 -1980 340 -1980 {
lab=xpt_otan_inp}
N 540 -1980 580 -1980 {
lab=xpt_otan_out}
N 310 -1960 340 -1960 {
lab=xpt_otan_inm}
N 540 -1460 580 -1460 {
lab=xpt_mirn_a}
N 540 -1440 580 -1440 {
lab=xpt_mirn_b}
N 1260 -1450 1300 -1450 {
lab=xpt_mirp_b}
N 1260 -1470 1300 -1470 {
lab=xpt_mirp_a}
N 310 -940 340 -940 {
lab=xpt_dpn_inp}
N 310 -920 340 -920 {
lab=xpt_dpn_inm}
N 540 -940 580 -940 {
lab=xpt_dpn_outp}
N 540 -920 580 -920 {
lab=xpt_dpn_outm}
N 1030 -940 1060 -940 {
lab=xpt_dpp_inp}
N 1030 -920 1060 -920 {
lab=xpt_dpp_inm}
N 1260 -940 1300 -940 {
lab=xpt_dpp_outp}
N 1260 -920 1300 -920 {
lab=xpt_dpp_outm}
N 310 -440 340 -440 {
lab=xpt_nfeta_d}
N 310 -420 340 -420 {
lab=xpt_nfeta_g}
N 310 -400 340 -400 {
lab=xpt_nfeta_s}
N 310 20 340 20 {
lab=xpt_nfetb_d}
N 310 40 340 40 {
lab=xpt_nfetb_g}
N 310 60 340 60 {
lab=xpt_nfetb_s}
N 1030 20 1060 20 {
lab=xpt_pfetb_d}
N 1030 40 1060 40 {
lab=xpt_pfetb_g}
N 1030 60 1060 60 {
lab=xpt_pfetb_s}
N 1030 -440 1060 -440 {
lab=xpt_pfeta_d}
N 1030 -420 1060 -420 {
lab=xpt_pfeta_g}
N 1030 -400 1060 -400 {
lab=xpt_pfeta_s}
N 2510 -2800 2510 -60 {bus=true
lab=bus_A[6:1]}
N 2330 -2570 2710 -2570 {
lab=VAPWR}
N 2330 -2410 2710 -2410 {
lab=VGND}
N 1950 -2610 2030 -2610 {bus=true
lab=cfga_vapwr[6:1]}
N 1950 -2450 2030 -2450 {bus=true
lab=cfga_vgnd[6:1]}
N 2330 -2250 2710 -2250 {
lab=xpt_otan_inp}
N 1950 -2290 2030 -2290 {bus=true
lab=cfga_otan_inp[3:1]}
N 2330 -2390 2510 -2390 {bus=true
lab=bus_A[6:1]}
N 2330 -2230 2500 -2230 {bus=true
lab=bus_A[3:1]}
N 1950 -2130 2030 -2130 {bus=true
lab=cfga_otan_out[6:1]}
N 2330 -2090 2710 -2090 {
lab=xpt_otan_out}
N 2330 -1930 2710 -1930 {
lab=xpt_mirn_a}
N 2330 -1770 2710 -1770 {
lab=xpt_mirp_a}
N 2330 -1610 2710 -1610 {
lab=xpt_dpn_inp}
N 2330 -1450 2710 -1450 {
lab=xpt_dpn_outp}
N 2330 -1290 2710 -1290 {
lab=xpt_dpp_inp}
N 2330 -1130 2710 -1130 {
lab=xpt_dpp_outp}
N 2330 -970 2710 -970 {
lab=xpt_nfeta_d}
N 2330 -1910 2510 -1910 {bus=true
lab=bus_A[6:1]}
N 2330 -1750 2510 -1750 {bus=true
lab=bus_A[6:1]}
N 2330 -1430 2510 -1430 {bus=true
lab=bus_A[6:1]}
N 2330 -1110 2510 -1110 {bus=true
lab=bus_A[6:1]}
N 2330 -950 2510 -950 {bus=true
lab=bus_A[6:1]}
N 2330 -790 2510 -790 {bus=true
lab=bus_A[6:1]}
N 2330 -630 2510 -630 {bus=true
lab=bus_A[6:1]}
N 2330 -470 2510 -470 {bus=true
lab=bus_A[6:1]}
N 2330 -310 2510 -310 {bus=true
lab=bus_A[6:1]}
N 2330 -150 2510 -150 {bus=true
lab=bus_A[6:1]}
N 2330 -810 2710 -810 {
lab=xpt_nfeta_g}
N 2330 -650 2710 -650 {
lab=xpt_nfeta_s}
N 2330 -490 2710 -490 {
lab=xpt_pfeta_d}
N 2330 -330 2710 -330 {
lab=xpt_pfeta_g}
N 2330 -170 2710 -170 {
lab=xpt_pfeta_s}
N 2330 -1590 2500 -1590 {bus=true
lab=bus_A[3:1]}
N 2330 -1270 2500 -1270 {bus=true
lab=bus_A[3:1]}
N 1950 -1970 2030 -1970 {bus=true
lab=cfga_mirn_a[6:1]}
N 1950 -1810 2030 -1810 {bus=true
lab=cfga_mirp_a[6:1]}
N 1950 -1650 2030 -1650 {bus=true
lab=cfga_dpn_inp[3:1]}
N 1950 -1490 2030 -1490 {bus=true
lab=cfga_dpn_outp[6:1]}
N 1950 -1330 2030 -1330 {bus=true
lab=cfga_dpp_inp[3:1]}
N 1950 -1170 2030 -1170 {bus=true
lab=cfga_dpp_outp[6:1]}
N 1950 -1010 2030 -1010 {bus=true
lab=cfga_nfeta_d[6:1]}
N 1950 -850 2030 -850 {bus=true
lab=cfga_nfeta_g[6:1]}
N 1950 -690 2030 -690 {bus=true
lab=cfga_nfeta_s[6:1]}
N 1950 -530 2030 -530 {bus=true
lab=cfga_pfeta_d[6:1]}
N 1950 -370 2030 -370 {bus=true
lab=cfga_pfeta_g[6:1]}
N 1950 -210 2030 -210 {bus=true
lab=cfga_pfeta_s[6:1]}
N 3830 -2270 3860 -2270 {
lab=VAPWR}
N 3830 -2250 3860 -2250 {
lab=VDPWR}
N 3830 -2190 3860 -2190 {
lab=VGND}
N 3830 -1950 3860 -1950 {
lab=VAPWR}
N 3830 -1930 3860 -1930 {
lab=VDPWR}
N 3830 -1870 3860 -1870 {
lab=VGND}
N 3830 -1790 3860 -1790 {
lab=VAPWR}
N 3830 -1770 3860 -1770 {
lab=VDPWR}
N 3830 -1710 3860 -1710 {
lab=VGND}
N 3830 -1630 3860 -1630 {
lab=VAPWR}
N 3830 -1610 3860 -1610 {
lab=VDPWR}
N 3830 -1550 3860 -1550 {
lab=VGND}
N 3830 -1470 3860 -1470 {
lab=VAPWR}
N 3830 -1450 3860 -1450 {
lab=VDPWR}
N 3830 -1390 3860 -1390 {
lab=VGND}
N 3830 -1310 3860 -1310 {
lab=VAPWR}
N 3830 -1290 3860 -1290 {
lab=VDPWR}
N 3830 -1230 3860 -1230 {
lab=VGND}
N 3830 -1150 3860 -1150 {
lab=VAPWR}
N 3830 -1130 3860 -1130 {
lab=VDPWR}
N 3830 -1070 3860 -1070 {
lab=VGND}
N 3830 -990 3860 -990 {
lab=VAPWR}
N 3830 -970 3860 -970 {
lab=VDPWR}
N 3830 -910 3860 -910 {
lab=VGND}
N 3830 -830 3860 -830 {
lab=VAPWR}
N 3830 -810 3860 -810 {
lab=VDPWR}
N 3830 -750 3860 -750 {
lab=VGND}
N 3830 -670 3860 -670 {
lab=VAPWR}
N 3830 -650 3860 -650 {
lab=VDPWR}
N 3830 -590 3860 -590 {
lab=VGND}
N 3830 -510 3860 -510 {
lab=VAPWR}
N 3830 -490 3860 -490 {
lab=VDPWR}
N 3830 -430 3860 -430 {
lab=VGND}
N 3830 -350 3860 -350 {
lab=VAPWR}
N 3830 -330 3860 -330 {
lab=VDPWR}
N 3830 -270 3860 -270 {
lab=VGND}
N 3830 -190 3860 -190 {
lab=VAPWR}
N 3830 -170 3860 -170 {
lab=VDPWR}
N 3830 -110 3860 -110 {
lab=VGND}
N 4010 -2780 4010 -40 {bus=true
lab=bus_B[6:1]}
N 3830 -2230 4210 -2230 {
lab=xpt_otan_inm}
N 3450 -2270 3530 -2270 {bus=true
lab=cfgb_otan_inm[3:1]}
N 3830 -2210 4000 -2210 {bus=true
lab=bus_B[3:1]}
N 3830 -1910 4210 -1910 {
lab=xpt_mirn_b}
N 3830 -1750 4210 -1750 {
lab=xpt_mirp_b}
N 3830 -1590 4210 -1590 {
lab=xpt_dpn_inm}
N 3830 -1430 4210 -1430 {
lab=xpt_dpn_outm}
N 3830 -1270 4210 -1270 {
lab=xpt_dpp_inm}
N 3830 -1110 4210 -1110 {
lab=xpt_dpp_outm}
N 3830 -950 4210 -950 {
lab=xpt_nfetb_d}
N 3830 -1890 4010 -1890 {bus=true
lab=bus_B[6:1]}
N 3830 -1730 4010 -1730 {bus=true
lab=bus_B[6:1]}
N 3830 -1410 4010 -1410 {bus=true
lab=bus_B[6:1]}
N 3830 -1090 4010 -1090 {bus=true
lab=bus_B[6:1]}
N 3830 -930 4010 -930 {bus=true
lab=bus_B[6:1]}
N 3830 -770 4010 -770 {bus=true
lab=bus_B[6:1]}
N 3830 -610 4010 -610 {bus=true
lab=bus_B[6:1]}
N 3830 -450 4010 -450 {bus=true
lab=bus_B[6:1]}
N 3830 -290 4010 -290 {bus=true
lab=bus_B[6:1]}
N 3830 -130 4010 -130 {bus=true
lab=bus_B[6:1]}
N 3830 -790 4210 -790 {
lab=xpt_nfetb_g}
N 3830 -630 4210 -630 {
lab=xpt_nfetb_s}
N 3830 -470 4210 -470 {
lab=xpt_pfetb_d}
N 3830 -310 4210 -310 {
lab=xpt_pfetb_g}
N 3830 -150 4210 -150 {
lab=xpt_pfetb_s}
N 3830 -1570 4000 -1570 {bus=true
lab=bus_B[3:1]}
N 3830 -1250 4000 -1250 {bus=true
lab=bus_B[3:1]}
N 3450 -1950 3530 -1950 {bus=true
lab=cfgb_mirn_b[6:1]}
N 3450 -1790 3530 -1790 {bus=true
lab=cfgb_mirp_b[6:1]}
N 3450 -1630 3530 -1630 {bus=true
lab=cfgb_dpn_inm[3:1]}
N 3450 -1470 3530 -1470 {bus=true
lab=cfgb_dpn_outm[6:1]}
N 3450 -1310 3530 -1310 {bus=true
lab=cfgb_dpp_inm[3:1]}
N 3450 -1150 3530 -1150 {bus=true
lab=cfgb_dpp_outm[6:1]}
N 3450 -990 3530 -990 {bus=true
lab=cfgb_nfetb_d[6:1]}
N 3450 -830 3530 -830 {bus=true
lab=cfgb_nfetb_g[6:1]}
N 3450 -670 3530 -670 {bus=true
lab=cfgb_nfetb_s[6:1]}
N 3450 -510 3530 -510 {bus=true
lab=cfgb_pfetb_d[6:1]}
N 3450 -350 3530 -350 {bus=true
lab=cfgb_pfetb_g[6:1]}
N 3450 -190 3530 -190 {bus=true
lab=cfgb_pfetb_s[6:1]}
N 200 -1480 340 -1480 {
lab=ibias}
N 310 -1910 340 -1910 {
lab=ibias}
N 310 -870 340 -870 {
lab=ibias}
N 540 -1480 580 -1480 {
lab=ibias_p}
N 1030 -1460 1060 -1460 {
lab=ibias_p}
N 1030 -870 1060 -870 {
lab=ibias_p}
N 3180 410 3210 410 {
lab=VAPWR}
N 3180 430 3210 430 {
lab=VDPWR}
N 3180 490 3210 490 {
lab=VGND}
N 3180 450 3360 450 {bus=true
lab=bus_A[6:1]}
N 3180 470 3360 470 {bus=true
lab=bus_B[6:1]}
N 2800 410 2880 410 {bus=true
lab=cfg_bus_short[6:1]}
N 200 -1890 340 -1890 {bus=true
lab=ctrl_otan_tail[1:0]}
N 200 -1870 340 -1870 {
lab=ctrl_otan_diode}
N 200 -1400 340 -1400 {bus=true
lab=ctrl_mirn_a[1:0]}
N 200 -1380 340 -1380 {bus=true
lab=ctrl_mirn_b[1:0]}
N 920 -1400 1060 -1400 {bus=true
lab=ctrl_mirp_a[1:0]}
N 920 -1380 1060 -1380 {bus=true
lab=ctrl_mirp_b[1:0]}
N 200 -850 340 -850 {bus=true
lab=ctrl_dpn_tail[1:0]}
N 200 -830 340 -830 {
lab=ctrl_dpn_source}
N 920 -850 1060 -850 {bus=true
lab=ctrl_dpp_tail[1:0]}
N 920 -830 1060 -830 {
lab=ctrl_dpp_source}
N 200 -340 340 -340 {bus=true
lab=ctrl_nfeta_width[1:0]}
N 200 -360 340 -360 {
lab=ctrl_nfeta_source}
N 200 120 340 120 {bus=true
lab=ctrl_nfetb_width[1:0]}
N 200 100 340 100 {
lab=ctrl_nfetb_source}
N 920 -340 1060 -340 {bus=true
lab=ctrl_pfeta_width[1:0]}
N 920 -360 1060 -360 {
lab=ctrl_pfeta_source}
N 920 120 1060 120 {bus=true
lab=ctrl_pfetb_width[1:0]}
N 920 100 1060 100 {
lab=ctrl_pfetb_source}
N 360 -2320 540 -2320 {bus=true
lab=bus_A[5:1]}
C {mirror_n.sym} 390 -1480 0 0 {name=x2}
C {devices/lab_pin.sym} 310 -2050 0 0 {name=p1 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 310 -2030 0 0 {name=p2 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 310 -1840 0 0 {name=p3 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 1030 -1540 0 0 {name=p4 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 1030 -1520 0 0 {name=p5 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 1030 -1350 0 0 {name=p6 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 310 -1540 0 0 {name=p7 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 310 -1520 0 0 {name=p8 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 310 -1350 0 0 {name=p9 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 310 -1010 0 0 {name=p10 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 310 -990 0 0 {name=p11 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 310 -800 0 0 {name=p12 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 1030 -1010 0 0 {name=p13 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 1030 -990 0 0 {name=p14 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 1030 -800 0 0 {name=p15 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 310 -490 0 0 {name=p16 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 310 -470 0 0 {name=p17 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 310 -310 0 0 {name=p18 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 310 -30 0 0 {name=p19 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 310 -10 0 0 {name=p20 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 310 150 0 0 {name=p21 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 1030 -490 0 0 {name=p22 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 1030 -470 0 0 {name=p23 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 1030 -310 0 0 {name=p24 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 1030 -30 0 0 {name=p25 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 1030 -10 0 0 {name=p26 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 1030 150 0 0 {name=p27 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -2570 0 0 {name=x10[6:1]}
C {devices/lab_pin.sym} 2360 -2610 0 1 {name=p28 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -2590 0 1 {name=p29 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -2530 0 1 {name=p30 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -2410 0 0 {name=x11[6:1]}
C {devices/lab_pin.sym} 2360 -2450 0 1 {name=p31 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -2430 0 1 {name=p32 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -2370 0 1 {name=p33 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -2250 0 0 {name=x12[3:1]}
C {devices/lab_pin.sym} 2360 -2290 0 1 {name=p34 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -2270 0 1 {name=p35 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -2210 0 1 {name=p36 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -2090 0 0 {name=x13[6:1]}
C {devices/lab_pin.sym} 2360 -2130 0 1 {name=p37 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -2110 0 1 {name=p38 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -2050 0 1 {name=p39 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1930 0 0 {name=x14[6:1]}
C {devices/lab_pin.sym} 2360 -1970 0 1 {name=p40 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1950 0 1 {name=p41 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1890 0 1 {name=p42 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1770 0 0 {name=x15[6:1]}
C {devices/lab_pin.sym} 2360 -1810 0 1 {name=p43 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1790 0 1 {name=p44 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1730 0 1 {name=p45 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1610 0 0 {name=x16[3:1]}
C {devices/lab_pin.sym} 2360 -1650 0 1 {name=p46 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1630 0 1 {name=p47 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1570 0 1 {name=p48 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1450 0 0 {name=x17[6:1]}
C {devices/lab_pin.sym} 2360 -1490 0 1 {name=p49 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1470 0 1 {name=p50 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1410 0 1 {name=p51 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1290 0 0 {name=x18[3:1]}
C {devices/lab_pin.sym} 2360 -1330 0 1 {name=p52 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1310 0 1 {name=p53 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1250 0 1 {name=p54 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -1130 0 0 {name=x19[6:1]}
C {devices/lab_pin.sym} 2360 -1170 0 1 {name=p55 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -1150 0 1 {name=p56 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -1090 0 1 {name=p57 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -970 0 0 {name=x20[6:1]}
C {devices/lab_pin.sym} 2360 -1010 0 1 {name=p58 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -990 0 1 {name=p59 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -930 0 1 {name=p60 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -810 0 0 {name=x21[6:1]}
C {devices/lab_pin.sym} 2360 -850 0 1 {name=p61 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -830 0 1 {name=p62 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -770 0 1 {name=p63 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -650 0 0 {name=x22[6:1]}
C {devices/lab_pin.sym} 2360 -690 0 1 {name=p64 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -670 0 1 {name=p65 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -610 0 1 {name=p66 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -490 0 0 {name=x23[6:1]}
C {devices/lab_pin.sym} 2360 -530 0 1 {name=p67 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -510 0 1 {name=p68 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -450 0 1 {name=p69 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -330 0 0 {name=x24[6:1]}
C {devices/lab_pin.sym} 2360 -370 0 1 {name=p70 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -350 0 1 {name=p71 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -290 0 1 {name=p72 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 2180 -170 0 0 {name=x25[6:1]}
C {devices/lab_pin.sym} 2360 -210 0 1 {name=p73 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2360 -190 0 1 {name=p74 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 2360 -130 0 1 {name=p75 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 2710 -2090 0 1 {name=p111 sig_type=std_logic lab=xpt_otan_out}
C {devices/lab_pin.sym} 310 -1980 0 0 {name=p112 sig_type=std_logic lab=xpt_otan_inp}
C {devices/lab_pin.sym} 310 -1960 0 0 {name=p113 sig_type=std_logic lab=xpt_otan_inm}
C {devices/lab_pin.sym} 580 -1980 0 1 {name=p114 sig_type=std_logic lab=xpt_otan_out}
C {devices/lab_pin.sym} 580 -1460 0 1 {name=p115 sig_type=std_logic lab=xpt_mirn_a}
C {devices/lab_pin.sym} 2710 -2250 0 1 {name=p116 sig_type=std_logic lab=xpt_otan_inp}
C {devices/lab_pin.sym} 580 -1440 0 1 {name=p109 sig_type=std_logic lab=xpt_mirn_b}
C {devices/lab_pin.sym} 1300 -1470 0 1 {name=p110 sig_type=std_logic lab=xpt_mirp_a}
C {devices/lab_pin.sym} 1300 -1450 0 1 {name=p118 sig_type=std_logic lab=xpt_mirp_b}
C {devices/lab_pin.sym} 2710 -1930 0 1 {name=p119 sig_type=std_logic lab=xpt_mirn_a}
C {devices/lab_pin.sym} 2710 -1770 0 1 {name=p121 sig_type=std_logic lab=xpt_mirp_a}
C {devices/lab_pin.sym} 310 -940 0 0 {name=p123 sig_type=std_logic lab=xpt_dpn_inp}
C {devices/lab_pin.sym} 310 -920 0 0 {name=p124 sig_type=std_logic lab=xpt_dpn_inm}
C {devices/lab_pin.sym} 580 -940 0 1 {name=p125 sig_type=std_logic lab=xpt_dpn_outp}
C {devices/lab_pin.sym} 580 -920 0 1 {name=p126 sig_type=std_logic lab=xpt_dpn_outm}
C {devices/lab_pin.sym} 2710 -1610 0 1 {name=p127 sig_type=std_logic lab=xpt_dpn_inp}
C {devices/lab_pin.sym} 2710 -1450 0 1 {name=p129 sig_type=std_logic lab=xpt_dpn_outp}
C {devices/lab_pin.sym} 1030 -940 0 0 {name=p131 sig_type=std_logic lab=xpt_dpp_inp}
C {devices/lab_pin.sym} 1030 -920 0 0 {name=p132 sig_type=std_logic lab=xpt_dpp_inm}
C {devices/lab_pin.sym} 1300 -940 0 1 {name=p133 sig_type=std_logic lab=xpt_dpp_outp}
C {devices/lab_pin.sym} 1300 -920 0 1 {name=p134 sig_type=std_logic lab=xpt_dpp_outm}
C {devices/lab_pin.sym} 2710 -1290 0 1 {name=p135 sig_type=std_logic lab=xpt_dpp_inp}
C {devices/lab_pin.sym} 2710 -1130 0 1 {name=p137 sig_type=std_logic lab=xpt_dpp_outp}
C {devices/lab_pin.sym} 310 -440 0 0 {name=p141 sig_type=std_logic lab=xpt_nfeta_d}
C {devices/lab_pin.sym} 310 -420 0 0 {name=p142 sig_type=std_logic lab=xpt_nfeta_g}
C {devices/lab_pin.sym} 310 -400 0 0 {name=p143 sig_type=std_logic lab=xpt_nfeta_s}
C {devices/lab_pin.sym} 2710 -970 0 1 {name=p144 sig_type=std_logic lab=xpt_nfeta_d}
C {devices/lab_pin.sym} 2710 -810 0 1 {name=p145 sig_type=std_logic lab=xpt_nfeta_g}
C {devices/lab_pin.sym} 2710 -650 0 1 {name=p146 sig_type=std_logic lab=xpt_nfeta_s}
C {devices/lab_pin.sym} 310 20 0 0 {name=p147 sig_type=std_logic lab=xpt_nfetb_d}
C {devices/lab_pin.sym} 310 40 0 0 {name=p148 sig_type=std_logic lab=xpt_nfetb_g}
C {devices/lab_pin.sym} 310 60 0 0 {name=p149 sig_type=std_logic lab=xpt_nfetb_s}
C {devices/lab_pin.sym} 1030 60 0 0 {name=p153 sig_type=std_logic lab=xpt_pfetb_d}
C {devices/lab_pin.sym} 1030 40 0 0 {name=p154 sig_type=std_logic lab=xpt_pfetb_g}
C {devices/lab_pin.sym} 1030 20 0 0 {name=p155 sig_type=std_logic lab=xpt_pfetb_s}
C {devices/lab_pin.sym} 1030 -400 0 0 {name=p156 sig_type=std_logic lab=xpt_pfeta_d}
C {devices/lab_pin.sym} 1030 -420 0 0 {name=p157 sig_type=std_logic lab=xpt_pfeta_g}
C {devices/lab_pin.sym} 1030 -440 0 0 {name=p158 sig_type=std_logic lab=xpt_pfeta_s}
C {devices/lab_pin.sym} 2710 -2570 0 1 {name=p165 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 2710 -2410 0 1 {name=p166 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 2710 -490 0 1 {name=p168 sig_type=std_logic lab=xpt_pfeta_d}
C {devices/lab_pin.sym} 2710 -330 0 1 {name=p169 sig_type=std_logic lab=xpt_pfeta_g}
C {devices/lab_pin.sym} 2710 -170 0 1 {name=p170 sig_type=std_logic lab=xpt_pfeta_s}
C {devices/lab_pin.sym} 2510 -2800 1 0 {name=p274 sig_type=std_logic lab=bus_A[6:1]}
C {devices/bus_connect_nolab.sym} 2500 -2230 0 0 {name=r1}
C {devices/lab_wire.sym} 2440 -2230 0 0 {name=p171 sig_type=std_logic lab=bus_A[3:1]}
C {devices/lab_wire.sym} 2450 -1590 0 0 {name=p172 sig_type=std_logic lab=bus_A[3:1]}
C {devices/lab_wire.sym} 2450 -1270 0 0 {name=p173 sig_type=std_logic lab=bus_A[3:1]}
C {devices/bus_connect_nolab.sym} 2500 -1590 0 0 {name=r2}
C {devices/bus_connect_nolab.sym} 2500 -1270 0 0 {name=r3}
C {devices/ipin.sym} 1950 -2610 0 0 {name=p174 lab=cfga_vapwr[6:1]}
C {devices/ipin.sym} 1950 -2450 0 0 {name=p175 lab=cfga_vgnd[6:1]}
C {devices/ipin.sym} 1950 -2290 0 0 {name=p176 lab=cfga_otan_inp[3:1]}
C {devices/ipin.sym} 1950 -2130 0 0 {name=p177 lab=cfga_otan_out[6:1]}
C {devices/ipin.sym} 1950 -1970 0 0 {name=p178 lab=cfga_mirn_a[6:1]}
C {devices/ipin.sym} 1950 -1810 0 0 {name=p179 lab=cfga_mirp_a[6:1]}
C {devices/ipin.sym} 1950 -1650 0 0 {name=p180 lab=cfga_dpn_inp[3:1]}
C {devices/ipin.sym} 1950 -1490 0 0 {name=p181 lab=cfga_dpn_outp[6:1]}
C {devices/ipin.sym} 1950 -1330 0 0 {name=p182 lab=cfga_dpp_inp[3:1]}
C {devices/ipin.sym} 1950 -1170 0 0 {name=p183 lab=cfga_dpp_outp[6:1]}
C {devices/ipin.sym} 1950 -1010 0 0 {name=p184 lab=cfga_nfeta_d[6:1]}
C {devices/ipin.sym} 1950 -850 0 0 {name=p185 lab=cfga_nfeta_g[6:1]}
C {devices/ipin.sym} 1950 -690 0 0 {name=p186 lab=cfga_nfeta_s[6:1]}
C {devices/ipin.sym} 1950 -530 0 0 {name=p187 lab=cfga_pfeta_d[6:1]}
C {devices/ipin.sym} 1950 -370 0 0 {name=p188 lab=cfga_pfeta_g[6:1]}
C {devices/ipin.sym} 1950 -210 0 0 {name=p189 lab=cfga_pfeta_s[6:1]}
C {tt_asw_3v3.sym} 3680 -2230 0 0 {name=x28[3:1]}
C {devices/lab_pin.sym} 3860 -2270 0 1 {name=p82 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -2250 0 1 {name=p83 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -2190 0 1 {name=p84 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1910 0 0 {name=x30[6:1]}
C {devices/lab_pin.sym} 3860 -1950 0 1 {name=p88 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1930 0 1 {name=p89 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1870 0 1 {name=p90 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1750 0 0 {name=x31[6:1]}
C {devices/lab_pin.sym} 3860 -1790 0 1 {name=p91 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1770 0 1 {name=p92 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1710 0 1 {name=p93 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1590 0 0 {name=x32[3:1]}
C {devices/lab_pin.sym} 3860 -1630 0 1 {name=p94 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1610 0 1 {name=p95 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1550 0 1 {name=p96 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1430 0 0 {name=x33[6:1]}
C {devices/lab_pin.sym} 3860 -1470 0 1 {name=p97 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1450 0 1 {name=p98 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1390 0 1 {name=p99 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1270 0 0 {name=x34[3:1]}
C {devices/lab_pin.sym} 3860 -1310 0 1 {name=p100 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1290 0 1 {name=p101 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1230 0 1 {name=p102 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -1110 0 0 {name=x35[6:1]}
C {devices/lab_pin.sym} 3860 -1150 0 1 {name=p103 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -1130 0 1 {name=p104 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -1070 0 1 {name=p105 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -950 0 0 {name=x36[6:1]}
C {devices/lab_pin.sym} 3860 -990 0 1 {name=p106 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -970 0 1 {name=p107 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -910 0 1 {name=p108 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -790 0 0 {name=x37[6:1]}
C {devices/lab_pin.sym} 3860 -830 0 1 {name=p117 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -810 0 1 {name=p120 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -750 0 1 {name=p122 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -630 0 0 {name=x38[6:1]}
C {devices/lab_pin.sym} 3860 -670 0 1 {name=p128 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -650 0 1 {name=p130 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -590 0 1 {name=p136 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -470 0 0 {name=x39[6:1]}
C {devices/lab_pin.sym} 3860 -510 0 1 {name=p138 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -490 0 1 {name=p139 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -430 0 1 {name=p140 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -310 0 0 {name=x40[6:1]}
C {devices/lab_pin.sym} 3860 -350 0 1 {name=p150 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -330 0 1 {name=p151 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -270 0 1 {name=p152 sig_type=std_logic lab=VGND}
C {tt_asw_3v3.sym} 3680 -150 0 0 {name=x41[6:1]}
C {devices/lab_pin.sym} 3860 -190 0 1 {name=p159 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3860 -170 0 1 {name=p160 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3860 -110 0 1 {name=p161 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 4210 -2230 0 1 {name=p163 sig_type=std_logic lab=xpt_otan_inm}
C {devices/lab_pin.sym} 4210 -1910 0 1 {name=p164 sig_type=std_logic lab=xpt_mirn_b}
C {devices/lab_pin.sym} 4210 -1750 0 1 {name=p167 sig_type=std_logic lab=xpt_mirp_b}
C {devices/lab_pin.sym} 4210 -1590 0 1 {name=p190 sig_type=std_logic lab=xpt_dpn_inm}
C {devices/lab_pin.sym} 4210 -1430 0 1 {name=p191 sig_type=std_logic lab=xpt_dpn_outm}
C {devices/lab_pin.sym} 4210 -1270 0 1 {name=p192 sig_type=std_logic lab=xpt_dpp_inm}
C {devices/lab_pin.sym} 4210 -1110 0 1 {name=p193 sig_type=std_logic lab=xpt_dpp_outm}
C {devices/lab_pin.sym} 4210 -950 0 1 {name=p194 sig_type=std_logic lab=xpt_nfetb_d}
C {devices/lab_pin.sym} 4210 -790 0 1 {name=p195 sig_type=std_logic lab=xpt_nfetb_g}
C {devices/lab_pin.sym} 4210 -630 0 1 {name=p196 sig_type=std_logic lab=xpt_nfetb_s}
C {devices/lab_pin.sym} 4210 -470 0 1 {name=p199 sig_type=std_logic lab=xpt_pfetb_d}
C {devices/lab_pin.sym} 4210 -310 0 1 {name=p200 sig_type=std_logic lab=xpt_pfetb_g}
C {devices/lab_pin.sym} 4210 -150 0 1 {name=p201 sig_type=std_logic lab=xpt_pfetb_s}
C {devices/lab_pin.sym} 4010 -2780 1 0 {name=p202 sig_type=std_logic lab=bus_B[6:1]}
C {devices/bus_connect_nolab.sym} 4000 -2210 0 0 {name=r4}
C {devices/lab_wire.sym} 3940 -2210 0 0 {name=p203 sig_type=std_logic lab=bus_B[3:1]}
C {devices/lab_wire.sym} 3950 -1570 0 0 {name=p204 sig_type=std_logic lab=bus_B[3:1]}
C {devices/lab_wire.sym} 3950 -1250 0 0 {name=p205 sig_type=std_logic lab=bus_B[3:1]}
C {devices/bus_connect_nolab.sym} 4000 -1570 0 0 {name=r5}
C {devices/bus_connect_nolab.sym} 4000 -1250 0 0 {name=r6}
C {devices/ipin.sym} 3450 -2270 0 0 {name=p208 lab=cfgb_otan_inm[3:1]}
C {devices/ipin.sym} 3450 -1950 0 0 {name=p210 lab=cfgb_mirn_b[6:1]}
C {devices/ipin.sym} 3450 -1790 0 0 {name=p211 lab=cfgb_mirp_b[6:1]}
C {devices/ipin.sym} 3450 -1630 0 0 {name=p212 lab=cfgb_dpn_inm[3:1]}
C {devices/ipin.sym} 3450 -1470 0 0 {name=p213 lab=cfgb_dpn_outm[6:1]}
C {devices/ipin.sym} 3450 -1310 0 0 {name=p214 lab=cfgb_dpp_inm[3:1]}
C {devices/ipin.sym} 3450 -1150 0 0 {name=p215 lab=cfgb_dpp_outm[6:1]}
C {devices/ipin.sym} 3450 -990 0 0 {name=p216 lab=cfgb_nfetb_d[6:1]}
C {devices/ipin.sym} 3450 -830 0 0 {name=p217 lab=cfgb_nfetb_g[6:1]}
C {devices/ipin.sym} 3450 -670 0 0 {name=p218 lab=cfgb_nfetb_s[6:1]}
C {devices/ipin.sym} 3450 -510 0 0 {name=p219 lab=cfgb_pfetb_d[6:1]}
C {devices/ipin.sym} 3450 -350 0 0 {name=p220 lab=cfgb_pfetb_g[6:1]}
C {devices/ipin.sym} 3450 -190 0 0 {name=p221 lab=cfgb_pfetb_s[6:1]}
C {devices/ipin.sym} 200 -1480 0 0 {name=p76 lab=ibias}
C {devices/lab_wire.sym} 300 -1480 0 0 {name=p77 sig_type=std_logic lab=ibias}
C {devices/lab_pin.sym} 310 -1910 0 0 {name=p78 sig_type=std_logic lab=ibias}
C {devices/lab_pin.sym} 310 -870 0 0 {name=p79 sig_type=std_logic lab=ibias}
C {devices/lab_pin.sym} 580 -1480 0 1 {name=p80 sig_type=std_logic lab=ibias_p}
C {devices/lab_pin.sym} 1030 -1460 0 0 {name=p81 sig_type=std_logic lab=ibias_p}
C {devices/lab_pin.sym} 1030 -870 0 0 {name=p85 sig_type=std_logic lab=ibias_p}
C {tt_asw_3v3.sym} 3030 450 0 0 {name=x42[6:1]}
C {devices/lab_pin.sym} 3210 410 0 1 {name=p86 sig_type=std_logic lab=VAPWR}
C {devices/lab_pin.sym} 3210 430 0 1 {name=p87 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 3210 490 0 1 {name=p162 sig_type=std_logic lab=VGND}
C {devices/ipin.sym} 2800 410 0 0 {name=p197 lab=cfg_bus_short[6:1]}
C {devices/lab_pin.sym} 3360 450 2 0 {name=p198 sig_type=std_logic lab=bus_A[6:1]}
C {devices/lab_pin.sym} 3360 470 2 0 {name=p206 sig_type=std_logic lab=bus_B[6:1]}
C {devices/ipin.sym} 200 -1890 0 0 {name=p207 lab=ctrl_otan_tail[1:0]}
C {devices/ipin.sym} 200 -1870 0 0 {name=p209 lab=ctrl_otan_diode}
C {devices/ipin.sym} 200 -1400 0 0 {name=p222 lab=ctrl_mirn_a[1:0]}
C {devices/ipin.sym} 200 -1380 0 0 {name=p223 lab=ctrl_mirn_b[1:0]}
C {devices/ipin.sym} 920 -1400 0 0 {name=p224 lab=ctrl_mirp_a[1:0]}
C {devices/ipin.sym} 920 -1380 0 0 {name=p225 lab=ctrl_mirp_b[1:0]}
C {devices/ipin.sym} 200 -850 0 0 {name=p226 lab=ctrl_dpn_tail[1:0]}
C {devices/ipin.sym} 200 -830 0 0 {name=p227 lab=ctrl_dpn_source}
C {devices/ipin.sym} 920 -850 0 0 {name=p228 lab=ctrl_dpp_tail[1:0]}
C {devices/ipin.sym} 920 -830 0 0 {name=p229 lab=ctrl_dpp_source}
C {devices/ipin.sym} 200 -340 0 0 {name=p230 lab=ctrl_nfeta_width[1:0]}
C {devices/ipin.sym} 200 -360 0 0 {name=p231 lab=ctrl_nfeta_source}
C {devices/ipin.sym} 200 120 0 0 {name=p232 lab=ctrl_nfetb_width[1:0]}
C {devices/ipin.sym} 200 100 0 0 {name=p233 lab=ctrl_nfetb_source}
C {devices/ipin.sym} 920 -340 0 0 {name=p234 lab=ctrl_pfeta_width[1:0]}
C {devices/ipin.sym} 920 -360 0 0 {name=p235 lab=ctrl_pfeta_source}
C {devices/ipin.sym} 920 120 0 0 {name=p236 lab=ctrl_pfetb_width[1:0]}
C {devices/ipin.sym} 920 100 0 0 {name=p237 lab=ctrl_pfetb_source}
C {devices/iopin.sym} 360 -2460 0 1 {name=p238 lab=VAPWR}
C {devices/iopin.sym} 360 -2420 0 1 {name=p239 lab=VDPWR}
C {devices/iopin.sym} 360 -2380 0 1 {name=p240 lab=VGND}
C {devices/iopin.sym} 360 -2320 0 1 {name=p241 lab=bus_A[5:1]}
C {devices/lab_wire.sym} 520 -2320 0 0 {name=p242 sig_type=std_logic lab=bus_A[5:1]}
C {ota_n.sym} 100 -1950 0 0 {name=x1}
C {mirror_p.sym} 1100 -1480 0 0 {name=x3}
C {diff_n.sym} 440 -890 0 0 {name=x4}
C {diff_p.sym} 1160 -890 0 0 {name=x5}
C {nmos_prog.sym} 110 -410 0 0 {name=x6}
C {nmos_prog.sym} 110 50 0 0 {name=x7}
C {pmos_prog.sym} 1160 -420 0 0 {name=x8}
C {pmos_prog.sym} 1160 40 0 0 {name=x9}
